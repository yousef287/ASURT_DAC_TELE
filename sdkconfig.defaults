## sdkconfig.defaults
```kconfig
CONFIG_FATFS_USE_FASTSEEK=y
CONFIG_FATFS_FAST_SEEK_BUFFER_SIZE=64
CONFIG_FATFS_LFN_MAX=255
CONFIG_FATFS_LFN=y
```
